# Keil uVision project Template.uvproj, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC131SD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x10FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: APROM_application +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: generateChecksum.bat
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC131\Include;..\..\..\..\Library\StdDriver\inc;..\..\AP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x1ffc
  memory RVCT10: RAM 0x20001ffc size 0x4
  link misc: --map --first='startup_NUC131.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC131/Source/: system_NUC131.c
    ../../../../Library/Device/Nuvoton/NUC131/Source/ARM/: startup_NUC131.s
  group Library
    ../../../../Library/StdDriver/src/: fmc.c clk.c retarget.c uart.c timer.c gpio.c sys.c
  group User
    ../: main.c
